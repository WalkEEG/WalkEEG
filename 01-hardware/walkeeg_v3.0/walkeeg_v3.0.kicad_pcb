# Repository WalkEEG/WalkEEG

File README.md:

# WalkEEG

**An open-source wearable biosignal platform for EEG, ECG and EMG.**

Schematics, firmware, mobile app, cloud backend — and a 500 Hz live browser dashboard.
Built for BCI research, education, and anyone curious about the electrical activity inside their body.

---

## What is this?

WalkEEG captures electrophysiological signals from the body, streams them wirelessly, and makes them visible in real time — on a phone, in a browser, or in a desktop oscilloscope.

| Signal | Source | Amplitude | Bandwidth |
|---|---|---|---|
| **EEG** — Electroencephalography | Cortical neurons firing together | 10 – 100 µV | 0.5 – 100 Hz |
| **ECG** — Electrocardiography | The electrical sequence pacing each heartbeat | 0.5 – 5 mV | 0.05 – 150 Hz |
| **EMG** — Electromyography | Motor units contracting a muscle | 10 – 1000 µV | 20 – 500 Hz |

These span **four orders of magnitude** in amplitude. A front end that handles all three rates its noise against the weakest (EEG) while keeping enough headroom for the strongest (EMG) — which is what an **80–120 dB CMRR** analog front end delivers.

---

## What's in the box

```
walkeeg/
├── 01-hardware/     KiCad schematics — analog front end, power, connectors
├── 02-firmware/     nRF52840 firmware (Zephyr / Nordic Connect SDK)
├── 03-PC program/   Desktop oscilloscope (LabVIEW, EN + Chinese)
├── 04-MATLAB program/ Analysis scripts (legacy, optional)
├── 05-Flutter program/ iOS + Android app
├── 06-website/      www.walkeeg.com (static, S3 + CloudFront)
├── 07-backend/      AWS SAM — one deployment example, not the platform
├── 08-realtime/     500 Hz WebSocket relay + live browser dashboard
├── algorithms/      Platform-neutral signal statistics (stdlib Python)
└── docs/            Design notes and interface specs
     └── algorithms/ Algorithm contracts + conformance tests
```

| Component | Stack | Status |
|---|---|---|
| **Hardware** | KiCad 10 · AD8232 + ADS1293 | v3.0 |
| **Firmware** | nRF52840 · Zephyr · BLE 5.0 (2M PHY, DLE, MTU 498) | working |
| **Mobile app** | Flutter 3.16+ · Dart 3.3+ | iOS + Android |
| **PC software** | LabVIEW | released |
| **Backend** | AWS SAM · Node 20 | deployed |
| **Live dashboard** | Node · WebSocket · vanilla JS | working |

---

## Quick start

### Firmware

The firmware targets the **nRF52840** and builds with Nordic Connect SDK. A complete, verified toolchain lives at `/opt/nordic/ncs/v2.5.99-dev1` on macOS — but any recent NCS works.

```bash
# 1. Source the NCS environment (adjust paths to your install)
export ZEPHYR_BASE=/path/to/ncs/zephyr
export ZEPHYR_TOOLCHAIN_VARIANT=zephyr
export ZEPHYR_SDK_INSTALL_DIR=/path/to/ncs/toolchains/*/opt/zephyr-sdk

# 2. Build from inside the NCS west workspace — not from the app dir
west build -b nrf52840dk/nrf52840 -d /tmp/build-walkeeg 02-firmware

# 3. Flash (Nordic boards)
nrfutil device recover   --serial-number <SN>
nrfutil device program   --serial-number <SN> --firmware /tmp/build-walkeeg/zephyr/zephyr.hex
nrfutil device reset     --serial-number <SN>
```

> **Building with J-Link instead?** Older J-Link firmware (e.g. V9) can fail to program the nRF52840 — erase succeeds, writes silently don't stick. Use `nrfutil` instead.

**Startup diagnostics.** The firmware blinks the run LED N times to report how far it got:

| Blinks | Meaning |
|---|---|
| 1 | `bt_enable()` OK |
| 2 | NUS service initialised |
| 3 | Analog front end initialised |
| 4 | BLE advertising started |
| 8 | `bt_le_adv_start()` failed |

### Mobile app

```bash
cd "05-Flutter program"
cp lib/config/app_config.example.dart lib/config/app_config.dart  # then fill in your AWS values
flutter pub get
flutter run
```

Requires Bluetooth permissions. On iOS, add `NSBluetoothAlwaysUsageDescription` to `Info.plist`.

### Live dashboard

```bash
cd 08-realtime
npm install
node server.js          # http://0.0.0.0:8787
node simulate.js        # optional: synthetic 500 Hz source
```

Open `http://<your-lan-ip>:8787`. The phone relays frames over WebSocket to `/ingest`; browsers subscribe at `/live`.

---

## How it works

```
    AD8232                  nRF52840                 Phone / PC
 ┌──────────┐   analog   ┌────────────┐    BLE    ┌────────────┐
 │ Electrodes│ ────────▶ │  SAADC     │ ────────▶ │  Flutter   │
 │  + AFE    │  10-1000µV│  + NUS GATT│  2 Mbps   │  app       │
 └──────────┘            └────────────┘           └─────┬──────┘
                                                        │ WebSocket
                                                        ▼
                                              ┌──────────────────┐
                                              │ 08-realtime      │
                                              │ browser dashboard│
                                              └──────────────────┘
```

1. **Acquire** — electrodes pick up microvolt-level potentials; the AFE amplifies and filters them.
2. **Transmit** — the nRF52840 digitises at 500 Hz – 4 kHz and streams over BLE 5.0 using Nordic UART Service, with 2M PHY, data-length extension (251-byte payloads) and a 498-byte MTU.
3. **Visualise** — the Flutter app renders live waveforms with QRS detection and HRV metrics.
4. **Store** — sessions upload to S3 via Cognito-authenticated direct PUT; metadata lands in DynamoDB.
5. **Share** — the app can relay raw frames to a local WebSocket server, so any browser on the network sees the same signal live.

### BLE packet format

```
magic 'W' (0x57) | version (1) | seq (u16 LE) | t_ms (u64 LE) | n (u8) | ch[8][n] (u16 LE)
└──────────────────────────── 13-byte header ─────────────────────────────┘
```

8 channels, 500 Hz, `n = 50` samples per batch → ~10 frames per second.

---

## Repository map

| Path | What you'll find |
|---|---|
| [`01-hardware/`](01-hardware) | KiCad 10 project, AD8232 / ADS1293 front ends, connector pinouts |
| [`02-firmware/`](02-firmware) | Zephyr application, board overlays, Kconfig switches |
| [`05-Flutter program/`](05-Flutter%20program) | Cross-platform app, BLE link, relay service |
| [`06-website/`](06-website) | Static site source, deployed to S3 + CloudFront |
| [`07-backend/`](07-backend) | AWS SAM deployment example (optional if you're not on AWS) |
| [`08-realtime/`](08-realtime) | WebSocket relay and browser charting |
| [`algorithms/`](algorithms) | Reusable signal statistics — stdlib Python, no cloud SDK |
| [`docs/`](docs) | Interface specs, migration notes, hardware revisions |
| [`docs/algorithms/`](docs/algorithms) | Platform-neutral signal processing contracts |

---

## Contributing

Issues and pull requests are welcome. Before opening a PR:

1. Keep the firmware buildable against current NCS — note the NCS version you tested with.
2. For hardware changes, attach the updated schematic PDF alongside the KiCad files.
3. For protocol changes, update `docs/` in the same commit.

## Where does algorithm code belong?

Signal processing is specified once in [`docs/algorithms/`](docs/algorithms) and
implemented once in [`algorithms/`](algorithms). That pair is the only place the
math should exist.

- **Real-time** algorithms run next to the data (app DSP, relay) — latency
  forbids a network round trip. They reimplement the contract for performance,
  and must match it.
- **Offline / batch** algorithms belong in `algorithms/`. `07-backend/` is just
  one way to run them, on one cloud. Swap it for cron, a Kubernetes job, or a
  laptop script without touching the math.
- Every implementation must satisfy
  [`docs/algorithms/conformance.md`](docs/algorithms/conformance.md) against the
  same fixtures.

Run the contract tests at any time:

```bash
python3 algorithms/python/conformance_test.py
```

See [CONTRIBUTING.md](CONTRIBUTING.md) for details (coming soon).

---

## License

MIT — see [LICENSE](LICENSE).

Copyright (c) 2026 the WalkEEG team · [www.walkeeg.com](https://www.walkeeg.com)

## KiCad design 01-hardware/walkeeg_v3.0/walkeeg_v3.0.kicad_pcb

Notes on the sheet:
Peripherals = 电源/USB/存储 (AMS1117, USB 磁珠防护, SPI Flash, SD, CH340)
WalkEEG v3.0 —— 8 通道便携脑电采集板
主控: nRF52840 模块 (青风) | 模拟前端: 8x AD8232 + ADS1293
页面说明: MotherBroad = 主控接口/模拟前端 (J1 J2 排针, 8x AD8232, ADS1293, 测试点)
外设: SPI Flash (W25Q80) / MicroSD / CH340C USB 串口

Parts:
J1, J2: Con_2_core; PinHeader_2x13_P2.54mm_Vertical
J3, J4, J5, J6, J7, J8, J9, J10: AD8232_connector; PinHeader_1x06_P2.54mm_Vertical
J11: ADS1293; PinHeader_2x05_P2.54mm_Vertical
J15: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
LED1, LED2: LED; LED_0805_2012Metric
R9, R10: 1k; R_0603_1608Metric
R11, R12, R13: 10k; R_0603_1608Metric
SW1: SW_Push; SW_Push_1P1T_NO_CK_KMR2
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP36, TP37, TP38, TP39, TP40, TP41, TP42, TP43, TP44, TP45, TP46, TP47, TP48, TP49, TP50, TP51, TP52: TestPoint; PinSocket_1x01_P2.54mm_Vertical

Connections:
+3V3: J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.1, J15.10, R9.1, R10.1, R12.1, R13.1; also elsewhere on the board
/MotherBroad/P0.00: J2.14, TP40.1 (1_1)
/MotherBroad/P0.01: J2.13, TP39.1 (1_1)
/MotherBroad/P0.02/AIN0: J2.8, J3.4, TP34.1 (1_1)
/MotherBroad/P0.03/AIN1: J2.7, J4.4, TP33.1 (1_1)
/MotherBroad/P0.04/AIN2: J2.17, J5.4, TP43.1 (1_1)
/MotherBroad/P0.05: TP44.1 (1_1)
/MotherBroad/P0.05/AIN3: J2.18, J6.4
/MotherBroad/P0.07/LO+: J2.20, J3.5, J4.5, J5.5, J6.5, J7.5, J8.5, J9.5, J10.5, R12.2, TP46.1 (1_1)
/MotherBroad/P0.09/NFC1: J1.2, TP2.1 (1_1)
/MotherBroad/P0.10/NFC2: J1.1, TP1.1 (1_1)
/MotherBroad/P0.11: TP50.1 (1_1)
/MotherBroad/P0.11/CS: J2.24, J15.6
/MotherBroad/P0.12: J1.26, TP26.1 (1_1)
/MotherBroad/P0.13: TP25.1 (1_1)
/MotherBroad/P0.13/SDO: J1.25, J15.4
/MotherBroad/P0.14: J1.24, TP24.1 (1_1)
/MotherBroad/P0.15: J1.23, TP23.1 (1_1)
/MotherBroad/P0.16: J1.22, TP22.1 (1_1)
/MotherBroad/P0.17/LED1: J1.21, LED1.1 (K), TP21.1 (1_1)
/MotherBroad/P0.18/RESET: J1.20, TP20.1 (1_1)
/MotherBroad/P0.19/LED2: J1.19, LED2.1 (K), TP19.1 (1_1)
/MotherBroad/P0.24/SDN: J1.14, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J9.3, J10.3, R11.1, TP14.1 (1_1)
/MotherBroad/P0.25/LO-: J1.13, J3.6, J4.6, J5.6, J6.6, J7.6, J8.6, J9.6, J10.6, R13.2, TP13.1 (1_1)
/MotherBroad/P0.26/SCL: J2.15, J15.5
/MotherBroad/P0.27/SDA: J2.16, J15.3
/MotherBroad/P0.28/AIN4: J2.9, J7.4, TP35.1 (1_1)
/MotherBroad/P0.29/AIN5: J2.10, J8.4, TP36.1 (1_1)
/MotherBroad/P0.30/AIN6: J2.11, J9.4, TP37.1 (1_1)
/MotherBroad/P0.31/AIN7: J2.12, J10.4, TP38.1 (1_1)
/MotherBroad/P1.00/ALARMB: J1.12, J11.9, TP12.1 (1_1)
/MotherBroad/P1.01: J1.11, SW1.1, TP11.1 (1_1)
/MotherBroad/P1.02/SDI: J1.8, J11.4, TP8.1 (1_1)
/MotherBroad/P1.03/SCLK: J1.7, J11.3, TP7.1 (1_1)
/MotherBroad/P1.04/SDO: J1.6, J11.5, TP6.1 (1_1)
/MotherBroad/P1.05/CSB: J1.5, J11.6, TP5.1 (1_1)
/MotherBroad/P1.06/DRDYB: J1.4, J11.7, TP4.1 (1_1)
/MotherBroad/P1.07/RSTB: J1.3, J11.8, TP3.1 (1_1)
/MotherBroad/P1.14: TP31.1 (1_1)
/MotherBroad/P1.14/INT1: J2.5, J15.7
/MotherBroad/P1.15: TP32.1 (1_1)
/MotherBroad/P1.15/INT2: J2.6, J15.8
/MotherBroad/SWCLK: J1.9, TP9.1 (1_1)
/MotherBroad/SWDIO: J1.10, TP10.1 (1_1)
D+: J2.26, TP52.1 (1_1); also elsewhere on the board
D-: J2.25, TP51.1 (1_1); also elsewhere on the board
GND: J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.2, J11.10, J15.9, R11.2, SW1.2; also elsewhere on the board
unnamed: LED1.2 (A), R9.2
unnamed: LED2.2 (A), R10.2
P0.06/TXD: J2.19, TP45.1 (1_1); also elsewhere on the board
P0.08/RXD: J2.21, TP47.1 (1_1); also elsewhere on the board
P0.20/MOSI: J1.18, TP18.1 (1_1); also elsewhere on the board
P0.21/MISO: J1.17, TP17.1 (1_1); also elsewhere on the board
P0.22/CS: J1.16, TP16.1 (1_1); also elsewhere on the board
P0.23/SCK: J1.15, TP15.1 (1_1); also elsewhere on the board
P0.26: TP41.1 (1_1)
P0.27: TP42.1 (1_1)
P1.08/RTS: J2.22, TP48.1 (1_1); also elsewhere on the board
P1.09/CTS: J2.23, TP49.1 (1_1); also elsewhere on the board
P1.10/SCK: J2.1, TP27.1 (1_1); also elsewhere on the board
P1.11/MOSI: J2.2, TP28.1 (1_1); also elsewhere on the board
P1.12/MISO: J2.3, TP29.1 (1_1); also elsewhere on the board
P1.13/CS: J2.4, TP30.1 (1_1); also elsewhere on the board

Parts:
C1, C2, C4, C5, C6, C8, C10, C12, C13: 100nF; C_0603_1608Metric
C3, C7, C9, C11: 10uF; C_0805_2012Metric
C14: 10nF; C_0603_1608Metric
FB1, FB2, FB3: 120R 0.55A; L_0603_1608Metric
J12: USB_B_Micro_UART; USB_Micro-B_Molex-105017-0001
J13: USB_B_Micro; USB_Micro-B_Molex-105017-0001
R1, R2, R3, R4, R5: 10k; R_0603_1608Metric
R7, R8: 220R; R_0603_1608Metric
U5: W25Q80DVSSIG; SOIC-8_3.9x4.9mm_P1.27mm
U6: Micro_SD_Card; microSD_HC_Hirose_DM3AT-SF-PEJM5
U7: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U8: AMS1117-3.3; SOT-223-3_TabPin2
U9: PRTR5V0U2X; SOT-143

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C9.1, C10.1, R1.2, R2.1, R3.2, R4.2, R5.2, U5.8 (VCC), U6.4 (VDD), U7.4 (V3), U7.16 (VCC), U8.2 (VO); also elsewhere on the board
/Peripherals/CH340_D+: J12.3 (D+), U7.5 (UD+)
/Peripherals/CH340_D-: J12.2 (D-), U7.6 (UD-)
/Peripherals/VBUS: C6.1, C7.1, C8.1, C11.1, C12.1, C13.1, C14.1, FB1.2, J12.1 (VBUS), U8.3 (VI), U9.4 (VCC)
D+: J13.3 (D+), U9.2 (I/O1); also elsewhere on the board
D-: J13.2 (D-), U9.3 (I/O2); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, FB2.2, FB3.2, J12.5 (GND), J12.SH (Shield), U5.4 (GND), U6.6 (VSS), U6.SH (SHIELD), U7.1 (GND), U8.1 (GND), U9.1 (GND); also elsewhere on the board
unnamed: FB3.1, J13.5 (GND), J13.SH (Shield)
unnamed: FB2.1, J13.4 (ID)
unnamed: FB1.1, J13.1 (VBUS)
unnamed: R1.1, U5.3 (IO2)
unnamed: R2.2, U5.7 (IO3)
unnamed: R3.1, U6.8 (DAT1)
unnamed: R4.1, U6.1 (DAT2)
unnamed: R8.2, U7.3 (RXD)
unnamed: R7.1, U7.2 (TXD)
P0.06/TXD: R8.1; also elsewhere on the board
P0.08/RXD: R7.2; also elsewhere on the board
P0.20/MOSI: U5.5 (IO0); also elsewhere on the board
P0.21/MISO: U5.2 (IO1); also elsewhere on the board
P0.22/CS: U5.1 (CS); also elsewhere on the board
P0.23/SCK: U5.6 (CLK); also elsewhere on the board
P1.08/RTS: U7.9 (~CTS); also elsewhere on the board
P1.09/CTS: U7.14 (~RTS); also elsewhere on the board
P1.10/SCK: U6.5 (CLK); also elsewhere on the board
P1.11/MOSI: U6.3 (CMD); also elsewhere on the board
P1.12/MISO: R5.1, U6.7 (DAT0); also elsewhere on the board
P1.13/CS: U6.2 (DAT3/CD); also elsewhere on the board

Notes on the sheet:
I2C 预留接口 —— LIS3DH 加速度计 (SCL=P0.26 SDA=P0.27, 经 J2-15/16)

Board: 2 copper layers, 107.0 x 137.0 mm, 106 parts (0 on the bottom side), 68 nets.

Other parts of the board:
H1: H1; MountingHole_3.2mm_M3
H2: H2; MountingHole_3.2mm_M3
H3: H3; MountingHole_3.2mm_M3

## Commit log (part)

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2016-10-20 :circus_tent: Added .gitattributes & .gitignore files
2016-10-20 First update
    WalkEEG reload
